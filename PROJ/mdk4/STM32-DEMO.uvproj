# Keil uVision project STM32-DEMO.uvproj, settings and files
target 百施通 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  AfterMake: fromelf --bin ..\..\PROJ\Output\STM32-DEMO.axf --output ..\..\PROJ\OutputBin\STM32-DEMO.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --c99
  c include: ..\..\CMSIS;..\..\MAIN;..\..\FWlib\inc;..\..\RTOS\include;..\..\RTOS\portable\RVDS\ARM_CM3;..\..\APPLICATION\reserve\inc;..\..\APPLICATION\am2320\inc;..\..\APPLICATION\led\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUPCODE
    ../../CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../CMSIS/: core_cm3.c system_stm32f10x.c
  group STM32/FWLIB
    ../../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_exti.c
  group RTOS/PORTABLE
    ../../RTOS/portable/RVDS/ARM_CM3/: port.c
    ../../RTOS/portable/MemMang/: heap_4.c
  group RTOS/CORE
    ../../RTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group MAIN
    ../../MAIN/: main.c app.c stm32f10x_it.c
  group 数据存储
    ../../APPLICATION/reserve/src/: reserve_flash.c
  group am2320
    ../../APPLICATION/am2320/src/: am2320.c am2320_bsp.c
  group LED
    ../../APPLICATION/led/src/: led.c led_bsp.c
